# Keil uVision project F407_ER-OLEDM0.uvprojx, settings and files
target F407_ER-OLEDM0 (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_ER-OLEDM0
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: F:\F407_ER-OLEDM0;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c HEHAL.c setup_Timer_Data.c setup_Flash.c
  group inc
    ./inc/: app.h init_LED.h delay.h init_I2C.h init_USART.h ssd1306.h fonts.h HEHAL.h bmp_180.h clock_RTC.h flash_F407.h button_F407.h setup_Timer_Data.h setup_Flash.h
  group init
    ./init/: init_LED.c delay.c init_I2C.c init_USART.c ssd1306.c fonts.c bmp_180.c clock_RTC.c flash_F407.c button_F407.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
